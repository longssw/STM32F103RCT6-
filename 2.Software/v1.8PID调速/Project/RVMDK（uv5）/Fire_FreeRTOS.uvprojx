# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target FreeRTOS_CAR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\key;..\..\Application;..\..\BSP;..\..\BSP\easylogger\inc;..\..\BSP\easylogger\port;..\..\BSP\easylogger\src;..\..\BSP\eMPL;..\..\BSP\cmd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h FreeRTOSConfig.h task_init.c
  group Application
    ../../Application/: led_task.c key_task.c oled_task.c mpu6050_task.c motor_task.c cmd_task.c adc_task.c
  group BSP
    ../../BSP/: bsp_init.c bsp_delay.c bsp_iic.c bsp_iic_oled.c bsp_iic_mpu6050.c bsp_adc.c bsp_tb6612.c bsp_pwm.c bsp_usart.c bsp_encoder.c bsp_pid.c
    ../../User/key/: bsp_key.c
    ../../User/Led/: bsp_led.c
  group EasyLogger
    ../../BSP/easylogger/src/: elog.c elog_utils.c
    ../../BSP/easylogger/port/: elog_port.c
    ../../BSP/easylogger/inc/: elog.h
  group MPU6050-DMP
    ../../BSP/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group CMD
    ../../BSP/cmd/: bsp_cmd.c bsp_buffer.c
